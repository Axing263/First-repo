# Keil uVision project Project.uvprojx, settings and files
target Project (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe  --bin -o  .\Objects\Project.bin   .\Objects\Project.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx
  c include: .\SYSTEM\delay;.\SYSTEM\sys;.\HARDWARE\RS485;.\HARDWARE\GPS;.\HARDWARE\RTC;.\HARDWARE\TIM;.\HARDWARE\ADC;.\HARDWARE\ML307R;.\HARDWARE\MQTT;.\HARDWARE\W25Q128;.\HARDWARE\SPI;.\HARDWARE\MD5;.\HARDWARE\CJSON;.\HARDWARE\MALLOC;.\HARDWARE\PROCESS;.\HARDWARE\ESP8266;.\HARDWARE\RC522
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUP
    ./: startup_stm32f40_41xxx.s
  group SYSTEM
    ./SYSTEM/delay/: delay.c
    ./SYSTEM/sys/: sys.c
  group HAEDWARE
    ./HARDWARE/RS485/: RS485.c
    ./HARDWARE/GPS/: GPS.c
    ./HARDWARE/RTC/: RTC.c
    ./HARDWARE/TIM/: TIM.c
    ./HARDWARE/ADC/: ADC.c
    ./HARDWARE/ML307R/: ML307R.c
    ./HARDWARE/MQTT/: MQTT.c
    ./HARDWARE/SPI/: SPI.c
    ./HARDWARE/W25Q128/: W25Q64.c
    ./HARDWARE/MD5/: MD5.c
    ./HARDWARE/MALLOC/: malloc.c
    ./HARDWARE/PROCESS/: Process.c
    ./HARDWARE/ESP8266/: ESP8266.c
    ./HARDWARE/RC522/: RC522.c
  group USER
    ./: main.c
  group README
    ./: README.txt
